options:
  parameters:
    generate_options: qt_gui
    id: example
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: IP_INFO
  id: variable
  parameters:
    value: '"addr=192.168.10.2"'
  states: {}
- name: centerFrequency
  id: variable
  parameters:
    value: '2442000000'
  states: {}
- name: nfft
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: sampleRate
  id: variable
  parameters:
    value: '50000000'
  states: {}
- name: trainedModel
  id: variable
  parameters:
    value: '"detect.pt"'
  states: {}
- name: vectorSize
  id: variable
  parameters:
    value: int(nfft*nfft)
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    minoutbuf: sampleRate//vectorSize
    num_items: vectorSize
    type: complex
  states: {}
- name: spectrumDetect_specDetect_1
  id: spectrumDetect_specDetect
  parameters:
    center_frequency: centerFrequency
    detect_json: 'False'
    gpu_device: '1'
    gpu_half: 'True'
    n_fft: nfft
    sample_rate: sampleRate
    trained_narrowband_model: xcit.ckpt
    trained_wideband_model: 11s.pt
    vector_size: vectorSize
    wb_detect_only: 'True'
    write_labeled_wb_images: 'False'
    write_nb_iq_file: 'False'
    write_wb_images: 'False'
    write_wb_iq_file: 'False'
    yolo_agnostic_nms: 'False'
    yolo_augment: 'False'
    yolo_conf: '0.25'
    yolo_iou: '0.7'
    yolo_max_det: '300'
  states: {}
- name: spectrumDetect_spectrumPlot_0
  id: spectrumDetect_spectrumPlot
  parameters:
    label: ''
    save: 'False'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: centerFrequency
    clock_rate: 200e6
    dev_args: IP_INFO
    gain0: '.7'
    gain_type0: normalized
    minoutbuf: sampleRate
    samp_rate: sampleRate
    start_time: '-1'
    sync: pc_clock_next_pps
    type: fc32
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', spectrumDetect_specDetect_1, '0']
- [spectrumDetect_specDetect_1, detect_pmt, spectrumDetect_spectrumPlot_0, detect_pmt]
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.9.1-12-gec7b2c40
